require recipes-devtools-iamcu/gcc/gcc-4.sc.iamcu.inc
require recipes-devtools/gcc/gcc-source.inc
