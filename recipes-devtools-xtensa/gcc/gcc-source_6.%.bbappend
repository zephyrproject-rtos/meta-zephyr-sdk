require gcc_6.%xtensa.inc
