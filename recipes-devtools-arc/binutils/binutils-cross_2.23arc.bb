require recipes-devtools/binutils/binutils.inc
require binutils-2.23arc.inc
require recipes-devtools/binutils/binutils-cross.inc

COMPATIBLE_MACHINE = "arc"