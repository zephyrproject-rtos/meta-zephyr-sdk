FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://add-trad-vectors-for-mips-elf.patch"
SRC_URI += "file://0001-Support-ARM-Cortex-M7.patch"
