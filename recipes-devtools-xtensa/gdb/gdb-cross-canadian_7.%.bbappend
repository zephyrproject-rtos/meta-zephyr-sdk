require gdb-7.%.inc
