require recipes-devtools/binutils/binutils.inc
require binutils-2.26arc.inc
require recipes-devtools/binutils/binutils-cross.inc

COMPATIBLE_MACHINE = "arc"
