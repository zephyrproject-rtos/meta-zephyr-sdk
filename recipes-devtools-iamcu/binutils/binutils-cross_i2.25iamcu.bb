require recipes-devtools/binutils/binutils.inc
require binutils-i2.25iamcu.inc
require recipes-devtools/binutils/binutils-cross.inc

COMPATIBLE_MACHINE = "iamcu"
