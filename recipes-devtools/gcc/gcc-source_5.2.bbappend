FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0042-arm-thumb2-multilib.patch"
SRC_URI += "file://gcc.git-716c563bcef8bb91dee230dbc75abff70ed2f6ae.patch"
