require recipes-devtools/gdb/gdb-common.inc
require recipes-devtools/gdb/gdb-cross-canadian.inc
require recipes-devtools-arc/gdb/gdb-7.5.1arc.inc
