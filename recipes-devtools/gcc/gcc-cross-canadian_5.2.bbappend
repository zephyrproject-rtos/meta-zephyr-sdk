
EXTRA_OECONF_append_libc-baremetal = " --enable-plugin"


